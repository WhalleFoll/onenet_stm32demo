# Keil uVision project TEST.uvprojx, settings and files
target 103ZET6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\SYS;..\ESP_MQTT_Onenet;..\ESP_MQTT_Onenet\MQTT;..\Libraies\inc;..\Libraies\CMSIS;..\My\inc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraies/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraies/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraies/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../README/: readme.txt
  group SYS
    ../SYS/: sys.c Tim.c usart.c delay.c MyEXTI.c
  group ESP_MQTT_Onenet
    ../ESP_MQTT_Onenet/: esp8266.c onenet.c
    ../ESP_MQTT_Onenet/MQTT/: MqttKit.c
  group My
    ../My/: beep.c key.c led.c dht11.c tsensor.c lcd.c Relay.c adc.c
  group USER
    ../User/: stm32f10x_it.c main.c
